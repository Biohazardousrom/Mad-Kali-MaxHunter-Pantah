## drivers/net/can/usb-can-2-module/Kconfig
```kconfig
config hlcan
        tristate "hlcan module for usb-can"
        depends on USB
        help
          Help message of hlcan
```
